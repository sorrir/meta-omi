SRC_URI += " \
	file://dropbear.default \
	"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
