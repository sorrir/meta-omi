PACKAGECONFIG_append = " networkd resolved polkit"
